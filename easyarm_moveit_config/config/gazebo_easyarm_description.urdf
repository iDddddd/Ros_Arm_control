Commit message: add easyarm_moveit

File: easyarm_moveit_config/config/gazebo_easyarm_description.urdf (robot description, URDF)
Before this commit: robot easyarm_description, 7 links, 6 joints
Links:
- removed link world
Joints:
- removed joint fixed
